# Keil uVision project Mainboard.uvprojx, settings and files
target Mainboard (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)   CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Mainboard +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,ARM_MATH_CM4,DEBUG_RTT,__FPU_PRESENT=1U,USE_FULL_ASSERT=1U
  c include: ../Inc;      ../../../STM32CubeF4/Drivers/STM32F4xx_HAL_Driver/Inc;      ../../../STM32CubeF4/Drivers/STM32F4xx_HAL_Driver/Inc\Legacy;      ../../../STM32CubeF4/Drivers/STM32F4xx_HAL_Driver/Middlewares/Third_Party/FreeRTOS/Source/include;      ../../../STM32CubeF4/Drivers/STM32F4xx_HAL_Driver/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;      ../../../STM32CubeF4/Drivers/STM32F4xx_HAL_Driver/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;      ../../../STM32CubeF4/Drivers/STM32F4xx_HAL_Driver/Drivers/CMSIS/Device/ST/STM32F4xx/Include;      ..\..\..\STM32CubeF4\Drivers\CMSIS\DSP\Include;      ..\RTT;      ..\RK_Shell\ringbuff\ringbuff\src/Include;      ../Inc\DNN;      ../Inc\GRU;      ../Inc\MFCC;      ..\..\..\STM32CubeF4\Drivers\STM32F4xx_HAL_Driver\Inc;      ../Drivers/STM32F4xx_HAL_Driver/Inc;      ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;      ../Middlewares/Third_Party/FreeRTOS/Source/include;      ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;      ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;      ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;      ../Drivers/CMSIS/Include;      ..\..\Common\include;      ..\Drivers\CMSIS\NN\Include;      ..\RTT;      ..\RK_Shell\ringbuff\ringbuff\src\include;      ..\CPU_Monitor;      ..\Drivers\CMSIS\DSP\DSP_Lib_TestSuite\RefLibs\inc;      ..\Fault;      ..\..\WifiBle\main
  asm include: ../Inc;..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: Mainboard\Mainboard.sct
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User
    ../Src/: voice_command.c test.c main.c freertos.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
    ../../WifiBle/main/: rk_serial_protocol.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group RTT
    ../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_GCC.c
  group Communication
    ../Src/: esp32.c
  group LCD
    ../Src/: lcd.c
  group Direction
    ../Src/: direction.c motor.c
  group RK_Shell
    ../RK_Shell/: app_cli.c vsm_shell.c
    ../RK_Shell/ringbuff/ringbuff/src/ringbuff/: ringbuff.c
  group Log
    ../Src/: log.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_fmc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_sdram.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group CPU_Monitor
    ../CPU_Monitor/: cpu_utils.c
  group DNN
    ../Src/DNN/: dnn.c
  group GRU
    ../Src/GRU/: gru.c
  group MFCC
    ../Src/MFCC/: mfcc.c
  group CMSIS
    ../Drivers/CMSIS/DSP/Source/BasicMathFunctions/: arm_abs_f32.c arm_abs_q7.c arm_abs_q15.c arm_abs_q31.c arm_add_f32.c arm_add_q7.c arm_add_q15.c arm_add_q31.c arm_dot_prod_f32.c arm_dot_prod_q7.c arm_dot_prod_q15.c arm_dot_prod_q31.c arm_mult_f32.c arm_mult_q7.c arm_mult_q15.c arm_mult_q31.c arm_negate_f32.c arm_negate_q7.c arm_negate_q15.c arm_negate_q31.c arm_offset_f32.c arm_offset_q7.c arm_offset_q15.c arm_offset_q31.c arm_scale_f32.c arm_scale_q7.c arm_scale_q15.c arm_scale_q31.c arm_shift_q7.c arm_shift_q15.c arm_shift_q31.c arm_sub_f32.c arm_sub_q7.c arm_sub_q15.c arm_sub_q31.c
    ../Drivers/CMSIS/NN/Source/FullyConnectedFunctions/: arm_fully_connected_mat_q7_vec_q15.c arm_fully_connected_mat_q7_vec_q15_opt.c arm_fully_connected_q7.c arm_fully_connected_q7_opt.c arm_fully_connected_q15.c arm_fully_connected_q15_opt.c
    ../Drivers/CMSIS/NN/Source/ActivationFunctions/: arm_nn_activations_q7.c arm_nn_activations_q15.c arm_relu_q7.c arm_relu_q15.c
    ../Drivers/CMSIS/DSP/Source/TransformFunctions/: arm_bitreversal.c arm_cfft_f32.c arm_cfft_q15.c arm_cfft_q31.c arm_cfft_radix2_f32.c arm_cfft_radix2_init_f32.c arm_cfft_radix2_init_q15.c arm_cfft_radix2_init_q31.c arm_cfft_radix2_q15.c arm_cfft_radix2_q31.c arm_cfft_radix4_f32.c arm_cfft_radix4_init_f32.c arm_cfft_radix4_init_q15.c arm_cfft_radix4_init_q31.c arm_cfft_radix4_q15.c arm_cfft_radix4_q31.c arm_cfft_radix8_f32.c arm_dct4_f32.c arm_dct4_init_f32.c arm_dct4_init_q15.c arm_dct4_init_q31.c arm_dct4_q15.c arm_dct4_q31.c arm_rfft_f32.c arm_rfft_fast_f32.c arm_rfft_fast_init_f32.c arm_rfft_init_f32.c arm_rfft_init_q15.c arm_rfft_init_q31.c arm_rfft_q15.c arm_rfft_q31.c
    ../Drivers/CMSIS/NN/Source/NNSupportFunctions/: arm_nn_mult_q7.c arm_nn_mult_q15.c arm_nntables.c arm_q7_to_q15_no_shift.c arm_q7_to_q15_reordered_no_shift.c
    ../Drivers/CMSIS/DSP/DSP_Lib_TestSuite/RefLibs/src/TransformFunctions/: cfft.c dct4.c rfft.c
    ../Drivers/CMSIS/DSP/Source/CommonTables/: arm_common_tables.c arm_const_structs.c
    ../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    ../Drivers/CMSIS/DSP/DSP_Lib_TestSuite/RefLibs/src/HelperFunctions/: mat_helper.c ref_helper.c
  group Fault
    ../Fault/: fault_handle.c fault_handle.h
software components: CMSIS:CORE 4.3.0
